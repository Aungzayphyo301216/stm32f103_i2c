# Keil uVision project stm32f103x_gpio_driver.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103x_gpio_driver
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application
    ./: main.c
  group HAL_Src
    ./: gpio_driver.c
  group HAL_Inc
    ./: gpio_driver.h
  group HAL_i2c_Src
    ./: i2c_driver.c
  group HAL_i2c_Inc
    ./: i2c_driver.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
